# Keil uVision project ASS6.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 Philips
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: ASS6
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ASS6.A51
